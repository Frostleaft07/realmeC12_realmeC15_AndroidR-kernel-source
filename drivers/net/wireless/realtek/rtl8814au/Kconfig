## drivers/net/wireless/realtek/rtl8814au/Kconfig
```kconfig
config RTL8814AU
	tristate "Realtek 8814A USB WiFi"
	depends on USB
	default m
	help
	  Help message of RTL8814AU
```
